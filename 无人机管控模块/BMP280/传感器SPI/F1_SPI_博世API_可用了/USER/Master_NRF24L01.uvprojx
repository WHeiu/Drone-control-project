# Keil uVision project Master_NRF24L01.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: systick +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\USER;..\FWlib\inc;..\CMSIS;.\BMP280;.\SPI;.\BMP280;.\SPI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c SPI_NRF.c usart1.c
    ./BMP280/: delay.c bmp280_support.c bmp280.c bmp280_support2.c
    ./SPI/: myspi.c
  group startup
    ../CMSIS/: startup_stm32f10x_hd.s
  group FWlib
    ../FWlib/src/: stm32f10x_gpio.c stm32f10x_spi.c stm32f10x_rcc.c stm32f10x_usart.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
software components: CMSIS:CORE 5.0.1
