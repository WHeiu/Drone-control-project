# Keil uVision project Test.uvprojx, settings and files
target Target 1 (5050169::V5.05 update 2 (build 169)::ARMCC)
  device: STM32F100C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Test +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_VL  USE_STDPERIPH_DRIVER
  c include: .\System;.\CORE;.\STM32F10x_FWLib\inc;.\TEXT;.\FATFS\src;.\User;.\Function
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Function
    ./Function/: myiic.c MS5611.c
  group Source Group 1
    ./CORE/: startup_stm32f10x_hd.s
  group User
    ./User/: main.c stm32f10x_it.c system_stm32f10x.c
  group System
    ./System/: delay.c sys.c usart.c
  group CORE
    ./CORE/: core_cm3.c
  group STM32F10x_FWLib
    ./STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
software components: CMSIS:CORE 4.1.0
